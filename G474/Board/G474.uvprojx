# Keil uVision project G474.uvprojx, settings and files
target G474 (6070000::V6.7::.\ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: G474 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: HSE1
  c include: ..\Board;..\Drivers\Inc;..\Drivers\Src;..\Include;..\System\Inc;..\System\Src;..\rt-thread\components\finsh;..\rt-thread\include;..\rt-thread\include\libc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Board
    ./: main.c board.c rtconfig.h system_stm32g4xx.c system_stm32g4xx.h
  group Drivers
    ../Drivers/Src/: led.c iic.c hard_iic.c usart.c
  group Core
    ./: startup_stm32g474xx.s
  group System
    ../System/Src/: delay.c sys.c mythread.c
  group rtt/source
    ../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group rtt/ports
    ../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
